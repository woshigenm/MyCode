ASSUME CS:CODE

CODE SEGMENT
START:
	
    CALL COPY_BOOT_FLP

	MOV AX, 4C00H
	INT 21H

; 此函数被加载到软盘的0面0道1扇区, 用于加载2,3扇区的代码到 0:7E00 处
BOOT:
	MOV AX, 07E0H
	PUSH AX
	MOV ES, AX
	MOV BX, 0H
	PUSH BX
	
	; 将 2 个扇区写入 0:7E00H 处
	MOV AL, 2 ;  2个
	MOV CH, 0 ; 0 磁道
	MOV CL, 2 ; 2 扇区
	MOV DH, 0 ; 0 面
	MOV DL, 0 ; A 软盘
	MOV AH, 2 ; 读
	INT 13H
	
	RETF
	
BOOT_END: NOP
	
; 此函数将BOOT函数加载到软盘的0面0道1扇区, 并将程序代码加载到2,3扇区
COPY_BOOT_FLP:
	JMP NEAR PTR COPY_BOOT_FLP_S
	FIRST_SECTOR DB 510 DUP(0) ; 引导2, 3扇区的代码
				 DB 55H, 0AAH ; 可引导扇区标志
	OTHER_SECTOR DB 2 * 512 DUP(0) ; 2, 3扇区的代码
COPY_BOOT_FLP_S :
	MOV AX, CS
	MOV DS, AX 
	MOV ES, AX
	LEA DI, CS:[FIRST_SECTOR] ; 目标地址 CS:FIRST_SECTOR
	LEA SI, CS:[BOOT] ; 数据源地址 CS:BOOT
	
	CLD ; 向后递增
	MOV CX, OFFSET BOOT_END - OFFSET BOOT
	REP MOVSB 
	
	MOV AX, CS
	MOV DS, AX 
	MOV ES, AX
	LEA DI, CS:[OTHER_SECTOR] ; 目标地址 CS:OTHER_SETOR
	LEA SI, CS:[FAN] ; 数据源地址 CS:FAN
	
	CLD ; 向后递增
	MOV CX, OFFSET FAN_END - OFFSET FAN
	REP MOVSB
	
	; ES:BX 存储位置
	MOV AX, CS
	MOV ES, AX
	LEA SI, CS:[FIRST_SECTOR]
	MOV BX, SI
	
	; 将 3 个扇区写入软盘
	MOV AL, 3 ;  3个
	MOV CH, 0 ; 0 磁道
	MOV CL, 1 ; 1 扇区
	MOV DH, 0 ; 0 面
	MOV DL, 0 ; A 软盘
	MOV AH, 3 ; 写
	INT 13H
	
	RET
	
FAN:
	JMP NEAR PTR FAN_S
	STRING1 DB '1) RETSET PC',0
	STACKS DB 128 DUP(0)
    STRING2 DB '2) START SYSTEM',0
    STRING3 DB '3) CLOCK',0
    STRING4 DB '4) SET CLOCK',0 
    STRING5 DB 'PLEASE INPUT(1-4):',0
    STRING_OFFSET DW STRING1 - FAN, STRING2 - FAN
                  DW STRING3 - FAN, STRING4 - FAN
                  DW STRING5 - FAN
    STRING_COUNTS DW 5
	INPUT_STRING DB 24 DUP(0)
FAN_S:
	MOV AX, CS
	INC AX
	MOV SS, AX
	MOV SP, 128
	
	; CALL CLEAR_SCREEN
	
	CALL PRINT_HELLO
	
	CALL HANDLE_INPUT
	
	JMP NEAR PTR FAN

HANDLE_INPUT:
	PUSH AX
	PUSH CX
	PUSH DX
	PUSH SI
	
	MOV AX, CS
	MOV DS, AX
	LEA SI, CS:[INPUT_STRING - FAN]
	
	MOV BX, SI
	
	MOV CL, 3
	MOV DX, 0412H
INPUT_LOOP:
    MOV AH, 0
    INT 16H
    CMP AL, 20H
    JB INPUT_LOOP_OVER 
    CMP AH, 0EH
    JE BACK
    CMP AH, 1CH
    JE INPUT_LOOP_OVER
    CALL CPUSH

    JMP SHORT INPUT_LOOP

BACK:
    CALL CPOP   
    JMP SHORT INPUT_LOOP
    
INPUT_LOOP_OVER:
	POP SI
	POP DX
	POP CX
	POP AX
	RET

; AL 入栈字符
CPUSH:
    MOV DS:[SI], AL
    CALL CSHOWS 
    INC SI
    RET
        
; AL 返回字符
CPOP:
    CMP SI, BX
    JE CPOP_OVER
    MOV AL, DS:[SI]
    DEC SI
    MOV BYTE PTR DS:[SI], 0
    CALL CSHOWS
CPOP_OVER:
    RET

CSHOWS:
    PUSH AX
    PUSH ES
    PUSH BX
    PUSH DX
    PUSH DI
	
    MOV AX, 0B800H
    MOV ES, AX
     
    XOR BX, BX
    
    MOV AL, 160
    MUL DH ; AX
    
    ADD BX, AX
    
    SHL DL, 1
    MOV DH, 0
    ADD BX, DX
    
    MOV AL, DS:[SI]         
    MOV ES:[BX], AL
	
	POP DI
    POP DX
    POP BX
    POP ES
    POP AX
    RET
	
CLEAR_SCREEN:
	PUSH AX
	PUSH CX
	PUSH ES
	PUSH DI
	
	MOV AX, 0B800H
	MOV ES, AX
	XOR DI, DI
	
	MOV AX, 0700H
	
	CLD
	MOV CX, 2000
	REP STOSW
	
	POP DI
	POP ES
	POP CX
	POP AX
	RET
	
PRINT_HELLO:
    PUSH AX
	PUSH BX
	PUSH CX
	PUSH DX
	PUSH DS
    
	MOV AX, CS
	MOV DS, AX
	MOV DX, 0000H
	
	XOR BX, BX
	
	MOV CX, CS:[STRING_COUNTS - FAN]
PRINT_HELLO_LOOP:
	PUSH CX
	
	MOV SI, CS:[STRING_OFFSET - FAN + BX]
	MOV CL, 3
	CALL PRINT
	INC DH
	
	ADD BX, 2
	POP CX
	LOOP PRINT_HELLO_LOOP
	
	POP DS
	POP DX
	POP CX
	POP BX
	POP AX
	RET

; DH:DL 行:列 CL 颜色 DS:SI 字符串首地址	
PRINT:
	PUSH AX
	PUSH BX
	PUSH CX
	PUSH DX
	PUSH ES
	PUSH SI
	
	MOV AX, 0B800H
	MOV ES, AX
	
	MOV AL, 160
	MUL DH
	
	MOV BX, AX
	
	SHL DL, 1
	XOR DH, DH
	ADD BX, DX
	
	MOV DH, CL
PRINT_LOOP:
	MOV DL, DS:[SI]
	CMP DL, 0
	JE PRINT_OVER
	MOV ES:[BX], DL
	ADD BX, 2
	INC SI
	JMP SHORT PRINT_LOOP
	
PRINT_OVER:	
	POP SI
	POP ES
	POP DX
	POP CX
	POP BX
	POP AX
	RET
	
FAN_END: NOP
	
CODE ENDS
END START
