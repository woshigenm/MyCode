ASSUME CS:CODE, SS:STACK

STACK SEGMENT
    DW 64 DUP(0)
STACK ENDS

DATA SEGMENT
	EXIT_STATUS  DW 0
DATA ENDS

CODE SEGMENT
START:
    MOV AX, STACK
    MOV SS, AX
    MOV SP, 128
	
	MOV AX, DATA
	MOV DS, AX
    
	MOV DS:[EXIT_STATUS], 0
	
	CALL CALL_CLOCK
        
    MOV AX, 4C00H
    INT 21H

CALL_CLOCK:
	PUSH CX
	PUSH DX
	PUSH SI
	PUSH DS
	
	CALL NEW_INT9_INSTALL
	
	MOV DX, 0C0FH
	MOV CL, 7
	LEA SI, CS:[TIME_STRING]
CALL_CLOCK_LOOP:
		CALL CLOCK
		CALL PRINT
		CALL DELAY
		CMP BYTE PTR DS:[EXIT_STATUS], 1H
		JE CALL_CLOCK_OVER
	JMP SHORT CALL_CLOCK_LOOP

CALL_CLOCK_OVER:	
	
	CALL RECOVER
	
	POP DS
	POP SI
	POP DX
	POP CX
	
	RET
           
CLOCK:
	JMP SHORT CLOCK_S
	TIME_STRING DB 'YYYY/MM/DD HH:MM:SS', 0
	TIME_OFFSET DW 9,8,7,4,2,0
CLOCK_S:
	PUSH AX
	PUSH BX
	PUSH CX
	PUSH SI
	
	MOV AL, 32h
	OUT 70H, AL
	IN AL, 71H
	
	CALL BCD
	
	MOV WORD PTR CS:[TIME_STRING], AX
	
	XOR BX, BX
	MOV SI, 2
	MOV CX, 6
CLOCK_LOOP:
		MOV AL, BYTE PTR  CS:[TIME_OFFSET + BX]
		OUT 70H, AL
		IN AL, 71H
		
		CALL BCD
		
		MOV WORD PTR CS:[TIME_STRING + SI], AX
		
		ADD SI, 3H
		ADD BX, 2H
	LOOP CLOCK_LOOP
	
	POP SI
	POP CX
	POP BX
	POP AX
	RET

; AL
BCD:
	PUSH CX
	
	MOV CL, 4H
	XOR AH, AH
	SHL AX, CL
	SHR AL, CL
	
	ADD AH, 30H
	ADD AL, 30H
	
	XCHG AH, AL
	
	POP CX
	RET
	
DELAY:
	PUSH AX
	PUSH DX
	
	MOV AX, 0FFFFH
	MOV DX, 0FH
	
	CLC
DELAY_LOOP:
	SUB AX, 1
	SBB DX, 0
	CMP BYTE PTR DS:[EXIT_STATUS], 1
	JE DELAY_OVER
	CMP AX, 0
	JNE DELAY_LOOP
	CMP DX, 0
	JNE DELAY_LOOP
	
DELAY_OVER:
	POP DX
	POP AX
	RET
	
NEW_INT9:
	PUSH AX
	PUSH BX
	PUSH CX
	PUSH ES
	
	IN AL, 60H
	
	PUSHF
	CALL DWORD PTR DS:[OLD_INT9]
	
	CMP AL, 03BH
	JE CHANGE_COLOR
	CMP AL, 01H
	JE EXIT
	
NEW_INT9_OVER:
	POP ES
	POP CX
	POP BX
	POP AX
	IRET
	
CHANGE_COLOR:
	MOV BX, 1
	MOV CX, 2000
	
	MOV AX, 0B800H
	MOV ES, AX
	CHANGE_COLOR_LOOP:
		INC BYTE PTR ES:[BX]
		ADD BX, 2
	LOOP CHANGE_COLOR_LOOP
JMP SHORT NEW_INT9_OVER

EXIT:
		MOV BYTE PTR DS:[EXIT_STATUS], 1
	JMP SHORT NEW_INT9_OVER

NEW_INT9_END: NOP
	
NEW_INT9_INSTALL:
	JMP SHORT NEW_INT9_INSTALL_S
	OLD_INT9 DW 0, 0
NEW_INT9_INSTALL_S:
	PUSH AX
	PUSH ES
	PUSH DI
	PUSH SI
	
	MOV AX, 0
	MOV ES, AX
	MOV DI, 200H
	
	MOV AX, CS
	MOV DS, AX
	
	MOV SI, OFFSET NEW_INT9
	
	PUSH ES:[4 * 9]
	POP DS:[OLD_INT9] ; IP
	PUSH ES:[4 * 9 + 2]
	POP DS:[OLD_INT9 + 2H] ; CS
	
	CLD
	MOV CX, OFFSET NEW_INT9_END - OFFSET NEW_INT9
	REP MOVSB
	
	CLI
	MOV WORD PTR ES:[4 * 9], 200H ; IP
	MOV WORD PTR ES:[4 * 9 + 2], 0H ; CS
	STI
	
	POP SI
	POP DI
	POP ES
	POP AX
	RET

RECOVER:
	PUSH AX
	PUSH ES
	PUSH DS
	
	MOV AX, 0
	MOV ES, AX
	
	CLI
	PUSH DS:[OLD_INT9] ; IP
	POP ES:[4 * 9]
	PUSH DS:[OLD_INT9 + 2] ; CS
	POP ES:[4 * 9 + 2]
	STI
	
	POP DS
	POP ES
	POP AX
	RET

PRINT:
	PUSH AX
	PUSH BX
	PUSH DX
	PUSH SI
	PUSH ES
	
	MOV BX, 0B800H
	MOV ES, BX
	
	MOV AL, 160
	MUL DH
	
	MOV BX, AX

	XOR DH, DH
	ADD DL, DL
	
	ADD BX, DX
	
	MOV DH, CL
PRINT_LOOP:
		MOV DL, DS:[SI]
		CMP DL, 0H
		JE PRINT_OVER
		
		MOV ES:[BX], DX
		
		ADD BX, 2H
		INC SI
	JMP SHORT PRINT_LOOP

PRINT_OVER:	
	POP ES
	POP SI
	POP DX
	POP BX
	POP AX
	RET
	
CODE ENDS
END START