# Keil uVision project LED.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c LCD1602.c LCD1602.h timer0.c timer0.h Buzzer.c Buzzer.h Delay.c Delay.h MatrixKey.c MatrixKey.h Nixie.c Nixie.h Key.c Key.h
