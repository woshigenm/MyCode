# Keil uVision project 7-2时钟芯片.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 7-2时钟芯片 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Delay.c Delay.h DS1302.c DS1302.h LCD1602.c LCD1602.h main.c Key.c Key.h Nixie.c Nixie.h timer0.c timer0.h MatrixKey.c MatrixKey.h
