# Keil uVision project 7-3AT24C02.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 7-3AT24C02 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Delay.c Delay.h Key.c Key.h LCD1602.c LCD1602.h STARTUP.A51 AT24C02.c AT24C02.h IIC.c IIC.h
