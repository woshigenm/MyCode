ASSUME CS:CODE, DS:DATA

DATA SEGMENT
	FIRST_SECTOR DB 510 DUP(0)
				 DB 055H, 0AAH
	OTHER_SECTOR DB 2 * 512 DUP(0)
DATA ENDS

CODE SEGMENT
START:
	MOV AX, DATA
	MOV DS, AX
	
	CALL COPY_BOOT_A
	
	MOV AX, 4C00H
	INT 21H

BOOT:
	MOV AX, 0
	MOV ES, AX
	PUSH AX
	MOV BX, 07E00H
	PUSH BX
	
	MOV AL, 2
	MOV CH, 0
	MOV CL, 2
	MOV DH, 0
	MOV DL, 0
	MOV AH, 2 
	INT 13H
	
	RETF
	
BOOT_END: NOP
	
COPY_BOOT_A:
	MOV AX, DATA
	MOV ES, AX
	LEA DI, DS:[FIRST_SECTOR]
	
	MOV AX, CS
	MOV DS, AX
	LEA SI, DS:[BOOT]
	
	CLD
	MOV CX, OFFSET BOOT_END - OFFSET BOOT
	REP MOVSB
	
	; OTHER_SECTOR
	MOV AX, DATA
	MOV ES, AX
	LEA DI, DS:[OTHER_SECTOR]
	
	MOV AX, CS
	MOV DS, AX
	LEA SI, DS:[COPY_CODE]
	
	CLD
	MOV CX, OFFSET COPY_CODE_END - OFFSET COPY_CODE
	REP MOVSB
	
	MOV AX, DATA
	MOV ES, AX
	LEA BX, DS:[FIRST_SECTOR]
	
	MOV AL, 3
	MOV CH, 0
	MOV CL, 1
	MOV DH, 0
	MOV DL, 0
	MOV AH, 3 
	INT 13H
	
	RET

; CS = 0 IP = 07E00H
COPY_CODE:
	JMP NEAR PTR SYSTEM_TOOLS
	STRING1 DB '1) RETSET PC',0
    STRING2 DB '2) START SYSTEM',0
    STRING3 DB '3) CLOCK',0
    STRING4 DB '4) SET CLOCK',0 
    STRING5 DB 'PLEASE INPUT(1-4):',0
    STRING_OFFSET DW STRING1 - COPY_CODE + 07E00H, STRING2 - COPY_CODE + 07E00H
                  DW STRING3 - COPY_CODE + 07E00H, STRING4 - COPY_CODE + 07E00H
                  DW STRING5 - COPY_CODE + 07E00H
	ALIGN_BYTES DB 13 DUP(0)
	STACKS DB 64 DUP(0)
	INPUT_STRING DB 24 DUP(0)
	ERROR_STRING DB 'INVAILD INPUT. PELASE INPUT(1-4). PRESS ANY KEY TO RETURN MENU.', 0
	TIME_OFFSET DW 9, 8, 7, 2, 4, 0
	TIME_STRING DB 'YYYY/MM/DD HH:MM:SS', 0
	TIME_EXIT DB 0
	OLD_INT9H DW 0, 0 ; 0000:7F19
SYSTEM_TOOLS:
		MOV AX, 07E06H
		MOV SS, AX
		MOV SP, 64
SYSTEM_TOOLS_S:
		CALL CLEAR_SCREEN
		
		CALL PRINT_HELLO
		
		CALL HANDLE_INPUT
		
	    ; CALL INSTALL_INT9H
		
		MOV AX, 07E0H
		MOV DS, AX
		
        LEA DI, DS:[INPUT_STRING - COPY_CODE]
		MOV AL, DS:[DI]
		
		CMP AL, '1'
		JB INPUT_ERROR
		CMP AL, '4'
		JA INPUT_ERROR
		
		CMP AL, '1'
		JE CALL_RESET
		
		CMP AL, '2'
		JE CAll_START_SYSTEM
		
		CMP AL, '3'
		JE CAll_SHOW_TIME
		
		JMP SHORT SYSTEM_TOOLS_S

INPUT_ERROR:
			CALL CLEAR_SCREEN
			CALL PRINT_ERROR_STRING
		JMP SHORT SYSTEM_TOOLS_S

CALL_RESET:
	CALL RESET	
	RET

CAll_START_SYSTEM:
	CALL START_SYSTEM
	RET

CAll_SHOW_TIME:
	PUSH AX
	PUSH DS
	PUSH SI
	PUSH DX
	PUSH CX
	
	MOV AX, 07E0H
	MOV DS, AX
	LEA SI, DS:[TIME_STRING - COPY_CODE]
	
	MOV DX, 0C20H
	MOV CL, 3
CALL_SHOW_TIME_LOOP:
		CALL GET_TIME
		CALL PRINT
		CALL DELAY
		CMP BYTE PTR DS:[TIME_EXIT - COPY_CODE], 1
	JNE CALL_SHOW_TIME_LOOP
	
	;CALL RESCUE
	
	POP CX
	POP DX
	POP SI
	POP DS
	POP AX
	RET
	
RESET:
	MOV AX, 0FFFFH
	PUSH AX
	MOV AX, 0H
	PUSH AX
	
	;CALL RESCUE
	
	RETF
	
	RET

START_SYSTEM:
	MOV BX, 0
	PUSH BX
	MOV ES, BX
	MOV BX, 07C00H
	PUSH BX
	
	MOV AL, 1
	MOV CH, 0
	MOV CL, 1
	MOV DH, 0
	MOV DL, 80H
	MOV AH, 2 
	INT 13H
	
	;CALL RESCUE
	
	RETF
	
	RET

GET_TIME:
	PUSH AX
	PUSH BX
	PUSH CX
	PUSH DS
	PUSH SI
	
	MOV AX, 07E0H
	MOV DS, AX
	
	MOV AL, 32H
	OUT 70H, AL
	IN AL, 71H
	
	CALL BCD
	
	MOV DS:[TIME_STRING - COPY_CODE], AX
	; TIME_OFFSET DW 9, 8, 7, 2, 4, 0
	XOR BX, BX
	MOV CX, 6
	MOV SI, 2
GET_TIME_LOOP:
		MOV AL, DS:[TIME_OFFSET - COPY_CODE][BX]
		OUT 70H, AL
		IN AL, 71H
		
		CALL BCD
		
		MOV DS:[TIME_STRING - COPY_CODE][SI], AX
		
		ADD BX, 2
		ADD SI, 3
	LOOP GET_TIME_LOOP
	
	POP SI
	POP DS
	POP CX
	POP BX
	POP AX
	RET

INSTALL_INT9H:
	PUSH AX
	PUSH CX
	PUSH ES
	PUSH DI
	PUSH DS
	PUSH SI
	
	MOV AX, 0
	MOV ES, AX
	MOV DI, 200H
	
	MOV AX, 07E0H
	MOV DS, AX
	LEA SI, DS:[INT9H - COPY_CODE] 
	
	PUSH ES:[4 * 9H] ; IP
	POP DS:[OLD_INT9H - COPY_CODE]
	PUSH ES:[4 * 9H + 2H] ; CS
	POP DS:[OLD_INT9H - COPY_CODE + 2]
	
	CLD
	MOV CX, OFFSET INT9H_END - OFFSET INT9H
	REP MOVSB
	
	CLI
	MOV WORD PTR ES:[4 * 9H], 200H
	MOV WORD PTR ES:[4 * 9H + 2H], 0H
	STI
	
	POP SI
	POP DS
	POP DI
	POP ES
	POP CX
	POP AX
	RET
	
INT9H:
	PUSH AX
	PUSH BX
	PUSH DS
	
	IN AL, 60H
	
	MOV BX, 07E0H
	MOV DS, BX
	
	PUSHF
	CALL DWORD PTR DS:[OLD_INT9H - COPY_CODE]
	
	CMP AL, 01H
	JE RETURN_MENU
	CMP AL, 03H
	JE CHANGE_COLOR
	
INT9H_OVER:
	POP DS
	POP BX
	POP AX
	IRET
	
RETURN_MENU:
	MOV BYTE PTR CS:[TIME_EXIT - COPY_CODE], 1H
	JMP SHORT INT9H_OVER
	
CHANGE_COLOR:
	MOV AX, 0B800H
	MOV ES, AX
	
	MOV BX, 1
	
	MOV CX, 2000
CHANGE_COLOR_LOOP:
		INC BYTE PTR ES:[BX]
		ADD BX, 2
	LOOP CHANGE_COLOR_LOOP
	
	JMP SHORT INT9H_OVER

INT9H_END: NOP

RESCUE:
	PUSH AX
	PUSH DS
	PUSH ES
	
	MOV AX, 0
	MOV ES, AX
	
	MOV AX, 07E0H
	MOV DS, AX
	
	CLI
	PUSH DS:[OLD_INT9H - COPY_CODE]
	POP ES:[4 * 9H] ; IP
	PUSH DS:[OLD_INT9H - COPY_CODE + 2]
	POP ES:[4 * 9H + 2H] ; CS
	STI	
	
	POP ES
	POP DS
	POP AX
	RET
	
; AL
BCD:
	PUSH CX
	
	XOR AH, AH
	
	MOV CL, 4
	SHL AX, CL
	SHR AL, CL
	
	ADD AH, 30H
	ADD AL, 30H
	
	XCHG AH, AL
	
	POP CX
	RET
	
DELAY:
	PUSH AX
	PUSH DX
	
	MOV AX, 0FFFFH
	MOV DX, 0FH
	
	CLC
DELAY_LOOP:
	SUB AX, 1
	SBB DX, 0
	CMP BYTE PTR CS:[TIME_EXIT - COPY_CODE], 1
	JE DELAY_LOOP_OVER
	CMP AX, 0
	JNE DELAY_LOOP
	CMP DX, 0
	JNE DELAY_LOOP
	
DELAY_LOOP_OVER:	
	POP DX
	POP AX
	RET
	
PRINT_ERROR_STRING:
	PUSH AX
	PUSH CX
	PUSH DX
	PUSH DS
	PUSH SI
	
	MOV AX, 07E0H
	MOV DS, AX
	LEA SI, DS:[ERROR_STRING - COPY_CODE]
	
	MOV DX, 0000H
	MOV CL, 4
	CALL PRINT
	
	MOV AH, 0
	INT 16H
	
	POP SI
	POP DS
	POP DX
	POP CX
	POP AX
	RET
	
HANDLE_INPUT:
	PUSH AX
	PUSH BX
	PUSH CX
	PUSH DX
	PUSH DS
	PUSH SI
	PUSH DI
	
	MOV AX, 07E0H
	MOV DS, AX
	
	LEA SI, DS:[INPUT_STRING - COPY_CODE]
	LEA BX, DS:[INPUT_STRING - COPY_CODE]
	LEA DI, DS:[INPUT_STRING - COPY_CODE + 24]
	
	MOV DX, 0412H
	MOV CL, 3
HANDLE_INPUT_LOOP:
		MOV AH, 0
		INT 16H
		
		CMP AH, 01CH
		JE HANDLE_INPUT_OVER
		CMP AH, 0EH
		JE HANDLE_BACK
		
		CMP BX, DI 
		JE HANDLE_INPUT_OVER
		CALL CHARPUSH
		
	JMP SHORT HANDLE_INPUT_LOOP

HANDLE_BACK:
		CMP BX, SI
		JE HANDLE_INPUT_LOOP
		CALL CHARPOP
	JMP SHORT HANDLE_INPUT_LOOP

HANDLE_INPUT_OVER:
	POP DI
	POP SI
	POP DS
	POP DX
	POP CX
	POP BX
	POP AX
	RET
	
; AL
CHARPUSH:
	MOV DS:[BX], AL
	CALL PRINT
	INC BX
	RET
	
CHARPOP:
	MOV BYTE PTR DS:[BX], 0
	DEC BX
	MOV BYTE PTR DS:[BX], ' '
	CALL PRINT
	RET
	

CLEAR_SCREEN:
	PUSH AX
	PUSH DX
	PUSH ES
	PUSH DI
	
	MOV AX, 0B800H
	MOV ES, AX
	
	XOR DI, DI
	MOV AX, 0700H
	
	CLD
	MOV CX, 2000
	REP STOSW
	
	POP DI
	POP ES
	POP DX
	POP AX
	RET

PRINT_HELLO:
	PUSH AX
	PUSH BX
	PUSH CX
	PUSH DX
	PUSH DS
	PUSH SI
	
	MOV AX, CS
	MOV DS, AX
	
	XOR BX, BX
	
	MOV DX, 0000H
	
	MOV CX, 5
PRINT_HELLO_LOOP:
		PUSH CX
		
		MOV CL, 3
        MOV SI, 07E00H[STRING_OFFSET - COPY_CODE][BX]
		CALL PRINT
		
		INC DH
		ADD BX, 2
		POP CX
	LOOP PRINT_HELLO_LOOP
	
	POP SI
	POP DS
	POP DX
	POP CX
	POP BX
	POP AX
	RET

; DH:DL CL DS:SI
PRINT:
	PUSH AX
	PUSH BX
	PUSH CX
	PUSH DX
	PUSH ES
	PUSH SI
	
	MOV AX, 0B800H
	MOV ES, AX
	
	MOV AL, 160
	MUL DH
	
	MOV BX, AX
	
	SHL DL, 1
	XOR DH, DH
	
	ADD BX, DX
	
	MOV DH, CL
PRINT_LOOP:
		MOV DL, DS:[SI]
		CMP DL, 0
		JE PRINT_OVER
		
		MOV ES:[BX], DL
		
		INC SI
		ADD BX, 2
	JMP SHORT PRINT_LOOP

PRINT_OVER:	
	POP SI
	POP ES
	POP DX
	POP CX
	POP BX
	POP AX
	RET
	
COPY_CODE_END: NOP
	
CODE ENDS
END START

