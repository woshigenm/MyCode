#include <REGX52.H>
#include "MATRIXLED.h"
#include "Delay.h"

//32
code unsigned char Face[] = {
	0x3C, 0x42, 0xA9, 0x85, 0x85, 0xA9, 0x42, 0x3C,
	0x3C, 0x42, 0xA5, 0x83, 0x83, 0xA5, 0x42, 0x3C,
	0x3C, 0x42, 0xA9, 0x85, 0x85, 0xA9, 0x42, 0x3C,
	0x3C, 0x42, 0xA9, 0x89, 0x89, 0xA9, 0x42, 0x3C,
	0x3C, 0x42, 0xA9, 0x91, 0x91, 0xA9, 0x42, 0x3C,
};

void main()
{
	unsigned char i, offset = 0, count = 0;

	MatrixLed_Init();
	while (1) {
		for (i = 0; i < 8; ++i) {
			MatrixLed_Show(i, Face[i + offset]);
		}

		if (count++ >= 10) {
			count = 0;
			offset += 8;
			if (offset >= sizeof(Face) - 7) {
				offset = 0;
			}
		}
	}
}