# Keil uVision project 7-1时钟芯片.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 7-1时钟芯片 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c DS1302.c DS1302.h LCD1602.c LCD1602.h Delay.c Delay.h
