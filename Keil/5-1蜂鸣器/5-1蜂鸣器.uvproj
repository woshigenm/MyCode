# Keil uVision project 5-1蜂鸣器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 5-1蜂鸣器
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 Buzzer.c Buzzer.h Delay.c Delay.h Key.c Key.h LCD1602.c LCD1602.h main.c Nixie.c Nixie.h timer0.c timer0.h
